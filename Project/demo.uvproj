# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\Inc
  group Core
    ./: STARTUP.A51
  group Src
    ../Src/: main.c bsp_lib.c smg.c ir.c
  group Inc
    ../Inc/: stc8g.h main.h bsp_lib.h smg.h ir.h
